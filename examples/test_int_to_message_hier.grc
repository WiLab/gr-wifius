<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_int_to_message_hier</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>test_int_to_message_hier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>type</key><value>message</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>strobe</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>strobe</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_message_strobe_0</sink_block_id><source_key>out0</source_key><sink_key>set_msg</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_message_strobe_0_0</sink_block_id><source_key>out1</source_key><sink_key>set_msg</sink_key></connection>
</flow_graph>
