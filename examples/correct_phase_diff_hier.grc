<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>delay_correct_hier</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Correct Phase Diff</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_size</value></param>
<param><key>value</key><value>int(2**( numpy.ceil(numpy.log(samp_rate/cal_tone_freq)/numpy.log(2))))</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_tone_freq</value></param>
<param><key>label</key><value>Calibration Tone Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mu</value></param>
<param><key>label</key><value>mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>synced</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>error</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>to_sync</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>ref</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0_0</value></param>
<param><key>label</key><value>enable_sync</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vec_size</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100000000/64</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>2</value></param>
</block>
<block>
<key>wifius_correct_input</key>
<param><key>id</key><value>wifius_correct_input_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wifius_int_to_message</key>
<param><key>id</key><value>wifius_int_to_message_0</value></param>
</block>
<block>
<key>wifius_shift_and_measure</key>
<param><key>id</key><value>wifius_shift_and_measure_0</value></param>
<param><key>cal_tone_freq</key><value>cal_tone_freq</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>vlen</key><value>vec_size</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>wifius_shift_and_measure_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>wifius_shift_and_measure_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_correct_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>wifius_blocker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0_0</source_block_id><sink_block_id>wifius_blocker_0</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>wifius_blocker_0</source_block_id><sink_block_id>blocks_complex_to_real_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_correct_input_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_int_to_message_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>message</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifius_int_to_message_0</source_block_id><sink_block_id>wifius_correct_input_0</sink_block_id><source_key>message</source_key><sink_key>set_delay</sink_key></connection>
<connection><source_block_id>wifius_shift_and_measure_0</source_block_id><sink_block_id>wifius_int_to_message_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_shift_and_measure_0</source_block_id><sink_block_id>pad_sink_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
