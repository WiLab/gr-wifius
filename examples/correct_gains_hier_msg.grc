<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>correct_gains_hier</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>description</key><value>Fix channel gain mismatch</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_tone_freq</value></param>
<param><key>label</key><value>Calibration Tone Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>Trigger</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0_0</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0_1</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0_1_0</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>wifius_divide_by_message</key>
<param><key>id</key><value>wifius_divide_by_message_0</value></param>
</block>
<block>
<key>wifius_divide_by_message</key>
<param><key>id</key><value>wifius_divide_by_message_0_0</value></param>
</block>
<block>
<key>wifius_divide_by_message</key>
<param><key>id</key><value>wifius_divide_by_message_0_1</value></param>
</block>
<block>
<key>wifius_divide_by_message</key>
<param><key>id</key><value>wifius_divide_by_message_0_1_0</value></param>
</block>
<block>
<key>wifius_find_scale_factor</key>
<param><key>id</key><value>wifius_find_scale_factor_0</value></param>
<param><key>cal_tone_freq</key><value>cal_tone_freq</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<block>
<key>wifius_find_scale_factor</key>
<param><key>id</key><value>wifius_find_scale_factor_0_0</value></param>
<param><key>cal_tone_freq</key><value>cal_tone_freq</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<block>
<key>wifius_find_scale_factor</key>
<param><key>id</key><value>wifius_find_scale_factor_0_1</value></param>
<param><key>cal_tone_freq</key><value>cal_tone_freq</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<block>
<key>wifius_find_scale_factor</key>
<param><key>id</key><value>wifius_find_scale_factor_0_1_0</value></param>
<param><key>cal_tone_freq</key><value>cal_tone_freq</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_divide_by_message_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_divide_by_message_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_divide_by_message_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_divide_by_message_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>wifius_blocker_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>wifius_blocker_0_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>wifius_blocker_0_0_1</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>wifius_blocker_0_0_1_0</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0</source_block_id><sink_block_id>wifius_find_scale_factor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0_0</source_block_id><sink_block_id>wifius_find_scale_factor_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0_1</source_block_id><sink_block_id>wifius_find_scale_factor_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0_1_0</source_block_id><sink_block_id>wifius_find_scale_factor_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_divide_by_message_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_divide_by_message_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>wifius_divide_by_message_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>wifius_divide_by_message_0_1_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>wifius_find_scale_factor_0</source_block_id><sink_block_id>wifius_divide_by_message_0</sink_block_id><source_key>message</source_key><sink_key>set_divisor</sink_key></connection>
<connection><source_block_id>wifius_find_scale_factor_0_0</source_block_id><sink_block_id>wifius_divide_by_message_0_0</sink_block_id><source_key>message</source_key><sink_key>set_divisor</sink_key></connection>
<connection><source_block_id>wifius_find_scale_factor_0_1</source_block_id><sink_block_id>wifius_divide_by_message_0_1</sink_block_id><source_key>message</source_key><sink_key>set_divisor</sink_key></connection>
<connection><source_block_id>wifius_find_scale_factor_0_1_0</source_block_id><sink_block_id>wifius_divide_by_message_0_1_0</sink_block_id><source_key>message</source_key><sink_key>set_divisor</sink_key></connection>
</flow_graph>
