<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>measure_phases</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>description</key><value>This block correct phase offsets between the input channels.  It works by measuring the relative peaks of each input sinusoid then delays the signals accordingly.  To provide stability only the most common offsets are taken from the past estimates.  The length of this history is controlled my the mode memory size parameter.  To reduce the overhead of this block the update period parameter will provide gaps between estimations, reducing overhead</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Measure Phase Offsets</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_size</value></param>
<param><key>value</key><value>samp_rate/cal_tone_freq*2</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>open</key><value>stopEstimating</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_0</value></param>
<param><key>open</key><value>stopEstimating</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_1</value></param>
<param><key>open</key><value>stopEstimating</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_1</value></param>
<param><key>vlen</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_2</value></param>
<param><key>vlen</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_2_0</value></param>
<param><key>vlen</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>102400</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>102400</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>102400</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>skip</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>skip</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_1</value></param>
<param><key>num_items</key><value>skip</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_items</key><value>vec_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_tone_freq</value></param>
<param><key>label</key><value>Calibration Tone Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enableLock</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Enable Lock</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Enabled</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>memSize</value></param>
<param><key>label</key><value>Mode Memory Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>message0</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>message1</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>message2</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>measurements</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>skip</value></param>
<param><key>label</key><value>Initial Samples Skipped</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stopEstimating</value></param>
<param><key>label</key><value>Disable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>updatePeriod</value></param>
<param><key>label</key><value>Update Period</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>wifius_int_to_message</key>
<param><key>id</key><value>wifius_int_to_message_0</value></param>
</block>
<block>
<key>wifius_int_to_message</key>
<param><key>id</key><value>wifius_int_to_message_0_0</value></param>
</block>
<block>
<key>wifius_int_to_message</key>
<param><key>id</key><value>wifius_int_to_message_0_1</value></param>
</block>
<block>
<key>wifius_measure_phases</key>
<param><key>id</key><value>wifius_measure_phases_0</value></param>
<param><key>CalibrationToneFrequency</key><value>cal_tone_freq</value></param>
<param><key>num_ports</key><value>3</value></param>
<param><key>SampleRate</key><value>samp_rate</value></param>
<param><key>UpdatePeriod</key><value>updatePeriod</value></param>
<param><key>vlen</key><value>vec_size</value></param>
</block>
<block>
<key>wifius_mode</key>
<param><key>id</key><value>wifius_mode_0</value></param>
<param><key>enableLocking</key><value>False</value></param>
<param><key>maxValue</key><value>vec_size</value></param>
<param><key>memSize</key><value>memSize</value></param>
<param><key>minValue</key><value>-vec_size</value></param>
</block>
<block>
<key>wifius_mode</key>
<param><key>id</key><value>wifius_mode_0_0</value></param>
<param><key>enableLocking</key><value>False</value></param>
<param><key>maxValue</key><value>vec_size</value></param>
<param><key>memSize</key><value>memSize</value></param>
<param><key>minValue</key><value>-vec_size</value></param>
</block>
<block>
<key>wifius_mode</key>
<param><key>id</key><value>wifius_mode_0_1</value></param>
<param><key>enableLocking</key><value>False</value></param>
<param><key>maxValue</key><value>vec_size</value></param>
<param><key>memSize</key><value>memSize</value></param>
<param><key>minValue</key><value>-vec_size</value></param>
</block>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_1</source_block_id><sink_block_id>wifius_measure_phases_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_2</source_block_id><sink_block_id>wifius_measure_phases_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_2_0</source_block_id><sink_block_id>wifius_measure_phases_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blks2_valve_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_head_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_1</source_block_id><sink_block_id>blks2_valve_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_1</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1_1</source_block_id><sink_block_id>blocks_complex_to_real_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>wifius_mode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0</source_block_id><sink_block_id>wifius_mode_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_0</source_block_id><sink_block_id>pad_sink_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0_0</source_block_id><sink_block_id>wifius_mode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_int_to_message_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>message</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifius_int_to_message_0_0</source_block_id><sink_block_id>pad_sink_0_0_0_1</sink_block_id><source_key>message</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifius_int_to_message_0_1</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>message</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifius_measure_phases_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_measure_phases_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_measure_phases_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mode_0</source_block_id><sink_block_id>wifius_int_to_message_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mode_0_0</source_block_id><sink_block_id>pad_sink_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mode_0_0</source_block_id><sink_block_id>wifius_int_to_message_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mode_0_1</source_block_id><sink_block_id>pad_sink_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>wifius_mode_0_1</source_block_id><sink_block_id>wifius_int_to_message_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
