<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ant_cal_enable</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>1,4</value></param>
<param><key>label</key><value>Enable Antenna Calibration</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.14159265359</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000000/32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snapshots</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>TX Direct (Top)</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0_0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>TX OTA (Bottom) </value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-90</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>180</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_0_0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_3</value></param>
<param><key>msg</key><value>pmt.from_double(ant_cal_enable)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>numpy.exp(-1j*phase_c0*pi/180)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>numpy.exp(-1j*phase_c1*pi/180)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>numpy.exp(-1j*phase_c2*pi/180)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>RX1</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>RX2</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>300</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"MuSIC Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>180</value></param>
<param><key>x_axis_label</key><value>"Offset"</value></param>
<param><key>x_start</key><value>-90</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>y_axis_label</key><value>"dB"</value></param>
</block>
<block>
<key>sync_tx_hier2</key>
<param><key>id</key><value>sync_tx_hier2_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>2.4e9</value></param>
<param><key>addr0</key><value>"addr=192.168.20.2"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>'Real'</value></param>
<param><key>gain_tx2</key><value>20</value></param>
</block>
<block>
<key>sync_tx_hier</key>
<param><key>id</key><value>sync_tx_hier_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>addr0</key><value>"addr=192.168.20.2"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>'Real'</value></param>
<param><key>gain_tx2</key><value>20</value></param>
</block>
<block>
<key>sync_tx_hier</key>
<param><key>id</key><value>sync_tx_hier_0_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>addr0</key><value>"addr=192.168.30.2"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>'Real'</value></param>
<param><key>gain_tx2</key><value>20</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_rx</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain_rx</value></param>
<param><key>ant2</key><value>RX2</value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain_rx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>3/4 USRP Sync with External Clock</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.40.2,addr1=192.168.50.2,addr2=192.168.60.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>mimo</value></param>
<param><key>time_source2</key><value>mimo</value></param>
<param><key>nchan</key><value>3</value></param>
<param><key>num_mboards</key><value>3</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>wifius_antenna_array_calibration_cf</key>
<param><key>id</key><value>wifius_antenna_array_calibration_cf_0</value></param>
<param><key>norm_antenna_spacing</key><value>0.5</value></param>
<param><key>num_antennas</key><value>3</value></param>
<param><key>num_snapshots</key><value>snapshots</value></param>
<param><key>angle</key><value>90</value></param>
</block>
<block>
<key>wifius_gen_music_spectrum_vcvf</key>
<param><key>id</key><value>wifius_gen_music_spectrum_vcvf_0</value></param>
<param><key>norm_spacing</key><value>0.5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>max_degree</key><value>90</value></param>
<param><key>min_degree</key><value>-90</value></param>
<param><key>num_antennas</key><value>3</value></param>
<param><key>snapshots</key><value>4096</value></param>
<param><key>num_sources</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sync_tx_hier2_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sync_tx_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>sync_tx_hier_0_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_3</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>strobe</source_key><sink_key>enable_hold</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>wifius_gen_music_spectrum_vcvf_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_gen_music_spectrum_vcvf_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
