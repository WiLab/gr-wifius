<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>calibration_example_gui</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>WiFiUS Project</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Calibration Example</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>antenna_spacing</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>antenna_spacing</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_spacing</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>option</key><value>cal_tone_freq</value></param>
<param><key>section</key><value>system</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>speed_of_light/(2*antenna_spacing)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>distant_tx</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Not Started</value></param>
<param><key>label1</key><value>Start Save</value></param>
<param><key>label</key><value>Distant TX</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>100000000/64</value></param>
<param><key>option</key><value>sample_rate</value></param>
<param><key>section</key><value>system</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>100000000/64</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samples_to_save</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>2**18</value></param>
<param><key>option</key><value>samples_to_save</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>speed_of_light</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sync</value></param>
<param><key>value</key><value>pmt.PMT_F</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>label1</key><value>Running</value></param>
<param><key>label</key><value>Sync System</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>pmt.PMT_F</value></param>
<param><key>option1</key><value>pmt.PMT_T</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>Source Enable</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_1_1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Not Started</value></param>
<param><key>label1</key><value>Start Save</value></param>
<param><key>label</key><value>Trigger Data Save</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_1_1)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_1</value></param>
<param><key>msg</key><value>sync</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_2</value></param>
<param><key>msg</key><value>pmt.from_double(distant_tx)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>doa_hier</key>
<param><key>id</key><value>doa_hier_0</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0</value></param>
<param><key>window</key><value>1024</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0</value></param>
<param><key>window</key><value>1024</value></param>
</block>
<block>
<key>phase_corrector</key>
<param><key>id</key><value>phase_corrector_0_0_0</value></param>
<param><key>window</key><value>1024</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>name</key><value>"Angle of Arrival"</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Angle</value></param>
<param><key>ymax</key><value>90</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>npoints</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>npoints</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>save_data_hier</key>
<param><key>id</key><value>save_data_hier_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>keep</key><value>1</value></param>
<param><key>samples</key><value>samples_to_save</value></param>
<param><key>skips</key><value>2**20</value></param>
<param><key>vec_size</key><value>64</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Post Phase Correct</value></param>
<param><key>label2</key><value>Angle of Arrival</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.90.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.80.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_rx</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain_rx</value></param>
<param><key>ant2</key><value></value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain_rx</value></param>
<param><key>ant3</key><value></value></param>
<param><key>center_freq3</key><value>center_freq</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>gain_rx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>3/4 USRP Sync with External Clock</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.70.2,addr1=192.168.20.2,addr2=192.168.30.2,addr3=192.168.50.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>clock_source3</key><value>external</value></param>
<param><key>time_source3</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>4</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0</value></param>
<param><key>default_state</key><value>False</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0</value></param>
<param><key>default_state</key><value>True</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>wifius_blocker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>wifius_blocker_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>wifius_blocker_0</sink_block_id><source_key>strobe</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>phase_corrector_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>phase_corrector_0_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>phase_corrector_0_0_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_2</source_block_id><sink_block_id>wifius_blocker_0_0</sink_block_id><source_key>strobe</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>doa_hier_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_corrector_0</source_block_id><sink_block_id>doa_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0</source_block_id><sink_block_id>doa_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0</source_block_id><sink_block_id>doa_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>phase_corrector_0_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>doa_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_corrector_0_0_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>wifius_blocker_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
