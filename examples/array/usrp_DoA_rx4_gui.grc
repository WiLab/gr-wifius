<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>calibration_example_gui</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>WiFiUS Project</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Calibration Example</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ant_cal_enable</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>1,4</value></param>
<param><key>label</key><value>Enable Antenna Calibration</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_spacing</value></param>
<param><key>value</key><value>antenna_spacing_inches*0.0254</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_spacing_inches</value></param>
<param><key>value</key><value>2.4</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>cal_tone_freq</value></param>
<param><key>section</key><value>system</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>speed_of_light/(2*antenna_spacing)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>distant_tx</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>Distant TX Ref</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>distant_tx_target</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>Distant TX Target</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>value</key><value>gain_rx_array</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rx_array</value></param>
<param><key>value</key><value>3</value></param>
<param><key>gui_hint</key><value>5,1</value></param>
<param><key>label</key><value>Gain RX Array</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_tx1</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
<param><key>label</key><value>Gain DRTX 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_tx2</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>4,1</value></param>
<param><key>label</key><value>Gain DRTX 2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label</value></param>
<param><key>value</key><value>Check To Enable</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Transmitter Control</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label2</value></param>
<param><key>value</key><value>Check To Enable</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>Algorithm  Control</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>label</key><value>Bias Angle</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-90</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_c3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Phase Channel3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>180</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.14159265359</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000000/64</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samples_to_save</value></param>
<param><key>config_file</key><value>/home/travis/Dropbox/PHD/WiFiUS/doa/gnuradio/gr-matlab/config.gr</value></param>
<param><key>value</key><value>2**18</value></param>
<param><key>option</key><value>samples_to_save</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>speed_of_light</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>sync</value></param>
<param><key>value</key><value>pmt.PMT_F</value></param>
<param><key>false</key><value>pmt.PMT_F</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label</key><value>Enable Sync Adaption</value></param>
<param><key>true</key><value>pmt.PMT_T</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sync</value></param>
<param><key>value</key><value>pmt.PMT_F</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>label1</key><value>Running</value></param>
<param><key>label</key><value>Sync System</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>pmt.PMT_F</value></param>
<param><key>option1</key><value>pmt.PMT_T</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>label</key><value>Connected Sync Tx</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>variable_qtgui_chooser_0_1_1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>label</key><value>Trigger Data Save</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_1_1)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_1</value></param>
<param><key>msg</key><value>sync</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_2</value></param>
<param><key>msg</key><value>pmt.from_double(distant_tx)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_2_0</value></param>
<param><key>msg</key><value>pmt.from_double(distant_tx_target)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_3</value></param>
<param><key>msg</key><value>pmt.from_double(ant_cal_enable)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>numpy.exp(-1j*2*pi*numpy.sin(phase_c0*pi/180))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>numpy.exp(-1j*2*pi*numpy.sin(phase_c1*pi/180))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>numpy.exp(-1j*2*pi*numpy.sin(phase_c2*pi/180))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>const</key><value>numpy.exp(-1j*2*pi*numpy.sin(phase_c3*pi/180))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>doa_ants_hier</key>
<param><key>id</key><value>doa_ants_hier_0</value></param>
<param><key>true_angle</key><value>90-33</value></param>
<param><key>snapshots</key><value>4096</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>phase_align_hier</key>
<param><key>id</key><value>phase_align_hier_0</value></param>
<param><key>step_size</key><value>0.001</value></param>
<param><key>update_period</key><value>32</value></param>
<param><key>window</key><value>window</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>name</key><value>"Angle of Arrival"</value></param>
<param><key>size</key><value>16</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Angle</value></param>
<param><key>ymax</key><value>90</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>180</value></param>
<param><key>x_axis_label</key><value>"Angle"</value></param>
<param><key>x_start</key><value>-90</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-10</value></param>
<param><key>y_axis_label</key><value>"dB"</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>npoints</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>npoints</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>save_data_hier</key>
<param><key>id</key><value>save_data_hier_0</value></param>
<param><key>keep</key><value>1</value></param>
<param><key>samples</key><value>2**16</value></param>
<param><key>skips</key><value>2**16</value></param>
<param><key>vec_size</key><value>64</value></param>
</block>
<block>
<key>sync_tx_hier</key>
<param><key>id</key><value>sync_tx_hier_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>addr0</key><value>"addr=192.168.60.2"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>"Complex"</value></param>
<param><key>gain_tx2</key><value>10</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Post Phase Correct</value></param>
<param><key>label2</key><value>Angle of Arrival</value></param>
<param><key>label3</key><value>MuSIC Spectrum</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>target_tx_hier</key>
<param><key>id</key><value>target_tx_hier_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>addr0</key><value>"addr=192.168.80.2"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>"Real"</value></param>
<param><key>gain_tx2</key><value>gain_tx2</value></param>
</block>
<block>
<key>target_tx_hier</key>
<param><key>id</key><value>target_tx_hier_0_0</value></param>
<param><key>cal_freq</key><value>10e3</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>addr0</key><value>"addr=192.168.90.2"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone_type</key><value>"Real"</value></param>
<param><key>gain_tx2</key><value>gain_tx1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_rx</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain_rx</value></param>
<param><key>ant2</key><value>RX2</value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain_rx</value></param>
<param><key>ant3</key><value>RX2</value></param>
<param><key>center_freq3</key><value>center_freq</value></param>
<param><key>dc_offs_enb3</key><value>""</value></param>
<param><key>iq_imbal_enb3</key><value>""</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>gain_rx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>3/4 USRP Sync with External Clock</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.20.2,addr1=192.168.30.2,addr2=192.168.40.2,addr3=192.168.50.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>clock_source3</key><value>external</value></param>
<param><key>time_source3</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>4</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>wifius_gen_music_spectrum_vcvf</key>
<param><key>id</key><value>wifius_gen_music_spectrum_vcvf_0</value></param>
<param><key>norm_spacing</key><value>0.5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>max_degree</key><value>90</value></param>
<param><key>min_degree</key><value>-90</value></param>
<param><key>num_antennas</key><value>4</value></param>
<param><key>snapshots</key><value>4096</value></param>
<param><key>num_sources</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sync_tx_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>phase_align_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_2</source_block_id><sink_block_id>target_tx_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_2_0</source_block_id><sink_block_id>target_tx_hier_0_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_3</source_block_id><sink_block_id>doa_ants_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>doa_ants_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>doa_ants_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>doa_ants_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>doa_ants_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>doa_ants_hier_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_align_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_align_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_align_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_align_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_align_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_align_hier_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_align_hier_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>phase_align_hier_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>wifius_gen_music_spectrum_vcvf_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
