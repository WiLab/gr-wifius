<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>calibration_example_gui</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>WiFiUS Project</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Calibration Example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_spacing</value></param>
<param><key>value</key><value>0.04</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>speed_of_light/(2*antenna_spacing)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000000/16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>speed_of_light</value></param>
<param><key>value</key><value>299792458</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>Source Enable</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_0_0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Enable</value></param>
<param><key>label1</key><value>Disable</value></param>
<param><key>label</key><value>Transmitter Enable</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_1_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>label1</key><value>Running</value></param>
<param><key>label</key><value>Sync System</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0_1_1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Not Started</value></param>
<param><key>label1</key><value>Start Save</value></param>
<param><key>label</key><value>Trigger Data Save</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>cal_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>open</key><value>variable_qtgui_chooser_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>open</key><value>variable_qtgui_chooser_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_1_0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.from_double(variable_qtgui_chooser_0_1_1)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>correct_gains_hier</key>
<param><key>id</key><value>correct_gains_hier_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate_0</key><value>samp_rate</value></param>
</block>
<block>
<key>delay_correct_hier</key>
<param><key>id</key><value>delay_correct_hier_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>0.00001</value></param>
</block>
<block>
<key>delay_correct_hier</key>
<param><key>id</key><value>delay_correct_hier_0_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>0.0001</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>npoints</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>npoints</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>real_time_scope_hier</key>
<param><key>id</key><value>real_time_scope_hier_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>npoints</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>save_data_hier</key>
<param><key>id</key><value>save_data_hier_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples</key><value>10000000</value></param>
<param><key>skips</key><value>10000</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Post Gain Correct</value></param>
<param><key>label2</key><value>Post Phase Correct</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.40.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.70.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_rx</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain_rx</value></param>
<param><key>ant2</key><value></value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain_rx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>3/4 USRP Sync with External Clock</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.20.2,addr1=192.168.30.2,addr2=192.168.50.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>nchan</key><value>3</value></param>
<param><key>num_mboards</key><value>3</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>wifius_counter_signal</key>
<param><key>id</key><value>wifius_counter_signal_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.from_double(1)</value></param>
<param><key>num_samples</key><value>2**25</value></param>
<param><key>printEvent</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blks2_valve_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>strobe</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>save_data_hier_0</sink_block_id><source_key>strobe</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>real_time_scope_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>real_time_scope_hier_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>real_time_scope_hier_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0</source_block_id><sink_block_id>real_time_scope_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>real_time_scope_hier_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wifius_counter_signal_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_counter_signal_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>message</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>wifius_counter_signal_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>message</source_key><sink_key>Trigger</sink_key></connection>
</flow_graph>
