<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>measure_offset</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Measure Offsets</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>label</key><value>Calibration Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>correct_gains_hier</key>
<param><key>id</key><value>correct_gains_hier_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate_0</key><value>samp_rate</value></param>
</block>
<block>
<key>delay_correct_hier_int</key>
<param><key>id</key><value>delay_correct_hier_int_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>delay_correct_hier_int</key>
<param><key>id</key><value>delay_correct_hier_int_0_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>delay_correct_hier_int</key>
<param><key>id</key><value>delay_correct_hier_int_0_1</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mu</value></param>
<param><key>label</key><value>mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_int_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>delay_correct_hier_int_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>out</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>delay_correct_hier_int_0</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>delay_correct_hier_int_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>delay_correct_hier_int_0_1</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
</flow_graph>
