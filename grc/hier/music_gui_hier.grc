<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>music_spectrum_hier_gui</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>MuSIC Spectrum GUI</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>d</value></param>
<param><key>label</key><value>Normalized Antenna Spacing</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>gains</value></param>
<param><key>label</key><value>GainEst</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>phases</value></param>
<param><key>label</key><value>PhaseEst</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"MuSIC Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>180</value></param>
<param><key>x_axis_label</key><value>"Offset"</value></param>
<param><key>x_start</key><value>-90</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>y_axis_label</key><value>"dB"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>snapshots</value></param>
<param><key>label</key><value>Num Snapshots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_signals</value></param>
<param><key>label</key><value>Source Signals</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>wifius_gen_music_spectrum_vcvf</key>
<param><key>id</key><value>wifius_gen_music_spectrum_vcvf_0</value></param>
<param><key>norm_spacing</key><value>d</value></param>
<param><key>step</key><value>1</value></param>
<param><key>max_degree</key><value>90</value></param>
<param><key>min_degree</key><value>-90</value></param>
<param><key>num_antennas</key><value>4</value></param>
<param><key>snapshots</key><value>snapshots</value></param>
<param><key>num_sources</key><value>source_signals</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>gains</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phases</source_block_id><sink_block_id>wifius_gen_music_spectrum_vcvf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>wifius_gen_music_spectrum_vcvf_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
