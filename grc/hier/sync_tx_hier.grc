<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sync_tx_hier</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>comment</key><value>Requires MIMO Cable</value></param>
<param><key>description</key><value>Transmitters directly connected to array</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Synchronizing TX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr0</value></param>
<param><key>label</key><value>Device Address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cal_freq/10</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_imag</key>
<param><key>id</key><value>blocks_complex_to_imag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>label</key><value>Calibration Tone Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_tx2</value></param>
<param><key>label</key><value>Transmitter Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Trigger</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100000000/256</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tone_type</value></param>
<param><key>label</key><value>Tone Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Real</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_tx2</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>wifius_blocker</key>
<param><key>id</key><value>wifius_blocker_0_0_0</value></param>
<param><key>default_state</key><value>True</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>wifius_blocker_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_imag_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_blocker_0_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_stop</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0_0</source_block_id><sink_block_id>blocks_complex_to_imag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_blocker_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
