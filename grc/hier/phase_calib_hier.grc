<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>phase_calib_hier</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Phase Calibration</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>gaincorrect</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>gaincorrect</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>input_index</key><value>gaincorrect</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1_0</value></param>
<param><key>input_index</key><value>gaincorrect</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>skips</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>skips</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_1</value></param>
<param><key>num_items</key><value>skips</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_2</value></param>
<param><key>num_items</key><value>skips</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cal_freq</value></param>
<param><key>label</key><value>Calibration Tone Freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>correct_gains_hier</key>
<param><key>id</key><value>correct_gains_hier_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate_0</key><value>samp_rate</value></param>
</block>
<block>
<key>delay_correct_hier</key>
<param><key>id</key><value>delay_correct_hier_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>delay_correct_hier</key>
<param><key>id</key><value>delay_correct_hier_0_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>delay_correct_hier</key>
<param><key>id</key><value>delay_correct_hier_0_0_0</value></param>
<param><key>cal_tone_freq</key><value>cal_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>mu</key><value>mu</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gaincorrect</value></param>
<param><key>label</key><value>Use Gain Correct (1 Yes, 0 No)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mu</value></param>
<param><key>label</key><value>mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>Sync_Enable</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>skips</value></param>
<param><key>label</key><value>Samples To Skip</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**14</value></param>
</block>
<block>
<key>wifius_correct_input</key>
<param><key>id</key><value>wifius_correct_input_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wifius_correct_input</key>
<param><key>id</key><value>wifius_correct_input_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wifius_correct_input</key>
<param><key>id</key><value>wifius_correct_input_0_1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>wifius_correct_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_1</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_1</source_block_id><sink_block_id>wifius_correct_input_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_2</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_2</source_block_id><sink_block_id>wifius_correct_input_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correct_gains_hier_0</source_block_id><sink_block_id>delay_correct_hier_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>offset</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>wifius_correct_input_0</sink_block_id><source_key>offset</source_key><sink_key>set_delay</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>offset</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0</source_block_id><sink_block_id>wifius_correct_input_0_0</sink_block_id><source_key>offset</source_key><sink_key>set_delay</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>offset</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0_0</source_block_id><sink_block_id>wifius_correct_input_0_1</sink_block_id><source_key>offset</source_key><sink_key>set_delay</sink_key></connection>
<connection><source_block_id>delay_correct_hier_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_skiphead_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>correct_gains_hier_0</sink_block_id><source_key>out</source_key><sink_key>Trigger</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>delay_correct_hier_0</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>delay_correct_hier_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>delay_correct_hier_0_0_0</sink_block_id><source_key>out</source_key><sink_key>enable_sync</sink_key></connection>
<connection><source_block_id>wifius_correct_input_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_correct_input_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_correct_input_0_1</source_block_id><sink_block_id>blks2_selector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
