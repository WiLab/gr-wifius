<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>doa_ants_hier</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>DoA Estimation With Calibration</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshots</value></param>
</block>
<block>
<key>matlab_doa_ants_cf</key>
<param><key>id</key><value>matlab_doa_ants_cf_0</value></param>
<param><key>snapshots</key><value>snapshots</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>angle</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>PhaseEst</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>GainEst</value></param>
<param><key>vlen</key><value>4</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>Trigger</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>snapshots</value></param>
<param><key>label</key><value>Number of Snapshots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>true_angle</value></param>
<param><key>label</key><value>Angle of Reference</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>wifius_antenna_array_calibration_cf</key>
<param><key>id</key><value>wifius_antenna_array_calibration_cf_0</value></param>
<param><key>norm_antenna_spacing</key><value>0.5</value></param>
<param><key>num_antennas</key><value>4</value></param>
<param><key>num_snapshots</key><value>snapshots</value></param>
<param><key>angle</key><value>true_angle</value></param>
</block>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_2</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>matlab_doa_ants_cf_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>wifius_antenna_array_calibration_cf_0</sink_block_id><source_key>out</source_key><sink_key>enable_hold</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>pad_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>matlab_doa_ants_cf_0</sink_block_id><source_key>1</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>wifius_antenna_array_calibration_cf_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
