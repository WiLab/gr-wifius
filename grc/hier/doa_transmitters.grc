<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>doa_txs</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>category</key><value>WiFiUS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>DoA Transmitters</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Transmitter</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_1</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_1_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>usrp_address</value></param>
<param><key>label</key><value>USRP IP(s)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"addr0=192.168.10.1"</value></param>
</block>
<block>
<key>wifius_mux_gate</key>
<param><key>id</key><value>wifius_mux_gate_0</value></param>
<param><key>default_output</key><value>-1</value></param>
<param><key>num_outputs</key><value>3</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>wifius_mux_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifius_mux_gate_0</sink_block_id><source_key>out</source_key><sink_key>select_output</sink_key></connection>
<connection><source_block_id>wifius_mux_gate_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mux_gate_0</source_block_id><sink_block_id>uhd_usrp_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifius_mux_gate_0</source_block_id><sink_block_id>uhd_usrp_sink_0_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
